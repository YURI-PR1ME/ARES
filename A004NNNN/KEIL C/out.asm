;==========================================================================
;====Power Disassembler for MCS-51 and 6502================================
;==========================================================================
;   Writen by: 覃远高
;   Copyright: 覃远高
;    HomePage: http://coolsh.163.net
;      E-mail: qinyg@163.net
;         Tel: 0755-2282553
;      Update: 3.Jul,2000/home/yuri/Downloads/keyongbin-885257-C51+�-_+Ζ?-?�?_1609574416
;==========================================================================
;===========Disassemble information========================================
;==========================================================================
;    File Name: C:\users\yuri\Desktop\ARES\A004NNNN\KEIL C\A004 LED.hex
;      IC Body: MCS-51  
;         Date: 12/19/2025
;==========================================================================
;==========================================================================
;标号==============指令================================地址===机器码=======
;==========================================================================
Q0000:             LJMP  Q00A6                        ;0000   02 00 A6
;==========================================================================
Q0003:             CLR   A                            ;0003   E4
                   MOV   08H,A                        ;0004   F5 08
                   MOV   09H,#01H                     ;0006   75 09 01
Q0009:             MOV   A,09H                        ;0009   E5 09
                   ADD   A,#0FEH                      ;000B   24 FE
                   JZ    Q0031                        ;000D   60 22
                   DEC   A                            ;000F   14
                   JZ    Q0054                        ;0010   60 42
                   DEC   A                            ;0012   14
                   JZ    Q006C                        ;0013   60 57
                   ADD   A,#03H                       ;0015   24 03
                   JNZ   Q0009                        ;0017   70 F0
                   SETB  P0.0                         ;0019   D2 80
                   SETB  P0.1                         ;001B   D2 81
                   CLR   P0.2                         ;001D   C2 82
                   CLR   P0.3                         ;001F   C2 83
                   SETB  P0.4                         ;0021   D2 84
                   SETB  P0.5                         ;0023   D2 85
                   MOV   R7,#0B8H                     ;0025   7F B8
                   MOV   R6,#0BH                      ;0027   7E 0B
                   LCALL Q0090                        ;0029   12 00 90
                   MOV   09H,#02H                     ;002C   75 09 02
                   SJMP  Q0009                        ;002F   80 D8
Q0031:             MOV   A,08H                        ;0031   E5 08
                   CLR   C                            ;0033   C3
                   SUBB  A,#0CH                       ;0034   94 0C
                   JNC   Q004C                        ;0036   50 14
                   CPL   P0.1                         ;0038   B2 81
                   MOV   R7,#2CH                      ;003A   7F 2C
                   MOV   R6,#01H                      ;003C   7E 01
                   LCALL Q0090                        ;003E   12 00 90
                   INC   08H                          ;0041   05 08
                   MOV   A,08H                        ;0043   E5 08
                   CJNE  A,#06H,Q0031                 ;0045   B4 06 E9
                   SETB  P0.2                         ;0048   D2 82
                   SJMP  Q0031                        ;004A   80 E5
Q004C:             CLR   A                            ;004C   E4
                   MOV   08H,A                        ;004D   F5 08
                   MOV   09H,#03H                     ;004F   75 09 03
                   SJMP  Q0009                        ;0052   80 B5
Q0054:             CLR   P0.0                         ;0054   C2 80
                   SETB  P0.1                         ;0056   D2 81
                   SETB  P0.2                         ;0058   D2 82
                   SETB  P0.3                         ;005A   D2 83
                   SETB  P0.4                         ;005C   D2 84
                   CLR   P0.5                         ;005E   C2 85
                   MOV   R7,#0D0H                     ;0060   7F D0
                   MOV   R6,#07H                      ;0062   7E 07
                   LCALL Q0090                        ;0064   12 00 90
                   MOV   09H,#04H                     ;0067   75 09 04
                   SJMP  Q0009                        ;006A   80 9D
Q006C:             MOV   A,08H                        ;006C   E5 08
                   CLR   C                            ;006E   C3
                   SUBB  A,#0CH                       ;006F   94 0C
                   JNC   Q0087                        ;0071   50 14
                   CPL   P0.4                         ;0073   B2 84
                   MOV   R7,#2CH                      ;0075   7F 2C
                   MOV   R6,#01H                      ;0077   7E 01
                   LCALL Q0090                        ;0079   12 00 90
                   INC   08H                          ;007C   05 08
                   MOV   A,08H                        ;007E   E5 08
                   CJNE  A,#06H,Q006C                 ;0080   B4 06 E9
                   SETB  P0.5                         ;0083   D2 85
                   SJMP  Q006C                        ;0085   80 E5
Q0087:             CLR   A                            ;0087   E4
                   MOV   08H,A                        ;0088   F5 08
                   MOV   09H,#01H                     ;008A   75 09 01
                   LJMP  Q0009                        ;008D   02 00 09
;==========================================================================
Q0090:             MOV   A,R7                         ;0090   EF
                   DEC   R7                           ;0091   1F
                   MOV   R2,06H                       ;0092   AA 06
                   JNZ   Q0097                        ;0094   70 01
                   DEC   R6                           ;0096   1E
Q0097:             ORL   A,R2                         ;0097   4A
                   JZ    Q00A5                        ;0098   60 0B
                   MOV   R5,#78H                      ;009A   7D 78
Q009C:             MOV   A,R5                         ;009C   ED
                   SETB  C                            ;009D   D3
                   SUBB  A,#00H                       ;009E   94 00
                   JC    Q0090                        ;00A0   40 EE
                   DEC   R5                           ;00A2   1D
                   SJMP  Q009C                        ;00A3   80 F7
Q00A5:             RET                                ;00A5   22
;==========================================================================
Q00A6:             MOV   R0,#7FH                      ;00A6   78 7F
                   CLR   A                            ;00A8   E4
Q00A9:             MOV   @R0,A                        ;00A9   F6
                   DJNZ  R0,Q00A9                     ;00AA   D8 FD
                   MOV   SP,#09H                      ;00AC   75 81 09
                   LJMP  Q0003                        ;00AF   02 00 03
;==========================================================================
