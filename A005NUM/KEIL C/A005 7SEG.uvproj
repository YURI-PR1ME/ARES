# Keil uVision project A005 7SEG.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: A005 7SEG +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/Documents and Settings/Administrator/×ÀÃæ/A005/KEIL C/: STARTUP.A51
    ./: A005 7SEG.c
