# Keil uVision project A010 KEY.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: A010 KEY +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/Documents and Settings/Administrator/桌面/A010/KEIL/: STARTUP.A51
    ./SRC/: main.c input_key.c system_init.c delay.c ledyiwei.c
