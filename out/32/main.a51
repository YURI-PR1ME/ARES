;==========================================================================
;====Power Disassembler for MCS-51 and 6502================================
;==========================================================================
;   Writen by: 覃远高
;   Copyright: 覃远高
;    HomePage: http://coolsh.163.net
;      E-mail: qinyg@163.net
;         Tel: 0755-2282553
;      Update: 3.Jul,2000
;==========================================================================
;===========Disassemble information========================================
;==========================================================================
;    File Name: C:\users\yuri\Desktop\ARES\A032NNNN\KEIL\A32.hex
;      IC Body: MCS-51  
;         Date: 12/19/2025
;==========================================================================
;==========================================================================
;标号==============指令================================地址===机器码=======
;==========================================================================
Q0000:             LJMP  Q0063                        ;0000   02 00 63
;==========================================================================
                   LJMP  Q0006                        ;0003   02 00 06
;==========================================================================
Q0006:             MOV   08H,#00H                     ;0006   75 08 00
                   RETI                               ;0009   32
;==========================================================================
Q000A:		 DB  00H, 02H, 00H, 2CH	;...,
;==========================================================================
Q000E:             LCALL Q0043                        ;000E   12 00 43
Q0011:             MOV   A,08H                        ;0011   E5 08
                   MOV   B,#0AH                       ;0013   75 F0 0A
                   DIV   AB                           ;0016   84
                   MOV   DPTR,#006FH                  ;0017   90 00 6F
                   MOVC  A,@A+DPTR                    ;001A   93
                   CPL   A                            ;001B   F4
                   MOV   P0,A                         ;001C   F5 80
                   MOV   A,08H                        ;001E   E5 08
                   MOV   B,#0AH                       ;0020   75 F0 0A
                   DIV   AB                           ;0023   84
                   MOV   A,B                          ;0024   E5 F0
                   MOVC  A,@A+DPTR                    ;0026   93
                   CPL   A                            ;0027   F4
                   MOV   P2,A                         ;0028   F5 A0
                   SJMP  Q0011                        ;002A   80 E5
                   PUSH  ACC                          ;002C   C0 E0
                   PUSH  B                            ;002E   C0 F0
                   PUSH  PSW                          ;0030   C0 D0
                   MOV   A,08H                        ;0032   E5 08
                   INC   A                            ;0034   04
                   MOV   B,#64H                       ;0035   75 F0 64
                   DIV   AB                           ;0038   84
                   MOV   08H,B                        ;0039   85 F0 08
                   POP   PSW                          ;003C   D0 D0
                   POP   B                            ;003E   D0 F0
                   POP   ACC                          ;0040   D0 E0
                   RETI                               ;0042   32
;==========================================================================
Q0043:             MOV   P0,#3FH                      ;0043   75 80 3F
                   MOV   P2,#3FH                      ;0046   75 A0 3F
                   LCALL Q0053                        ;0049   12 00 53
                   LCALL Q0079                        ;004C   12 00 79
                   MOV   IP,#02H                      ;004F   75 B8 02
                   RET                                ;0052   22
;==========================================================================
Q0053:             MOV   TMOD,#06H                    ;0053   75 89 06
                   MOV   TH0,#0FFH                    ;0056   75 8C FF
                   MOV   TL0,#0FFH                    ;0059   75 8A FF
                   SETB  EA                           ;005C   D2 AF
                   SETB  ET0                          ;005E   D2 A9
                   SETB  TR0                          ;0060   D2 8C
                   RET                                ;0062   22
;==========================================================================
Q0063:             MOV   R0,#7FH                      ;0063   78 7F
                   CLR   A                            ;0065   E4
Q0066:             MOV   @R0,A                        ;0066   F6
                   DJNZ  R0,Q0066                     ;0067   D8 FD
                   MOV   SP,#08H                      ;0069   75 81 08
                   LJMP  Q000E                        ;006C   02 00 0E
;==========================================================================
Q006F:		 DB 0C0H,0F9H,0A4H,0B0H, 99H, 92H, 82H,0F8H	;........
Q0077:		 DB  80H, 90H	;..
;==========================================================================
Q0079:             SETB  EA                           ;0079   D2 AF
                   SETB  EX0                          ;007B   D2 A8
                   SETB  IT0                          ;007D   D2 88
                   RET                                ;007F   22
;==========================================================================
