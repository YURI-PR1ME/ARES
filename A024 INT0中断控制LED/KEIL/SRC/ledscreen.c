/***********************************************
** ledscreen.c:8*8LED点阵屏显示程序，循环显示0-9
** void ledscreen(void);
************************************************/

#include "config.h"
#include "intrins.h"

//点阵屏的列选变量
uch8 en_row_leds;
//数字0的列码数组
uch8 code_row_leds[]=
{
 	0x00,0x3e,0x41,0x41,0x41,0x3e,0x00,0x00,//0
	0x00,0x00,0x00,0x21,0x7f,0x01,0x00,0x00,//1
	0x00,0x27,0x45,0x45,0x45,0x39,0x00,0x00,//2
	0x00,0x22,0x49,0x49,0x49,0x36,0x00,0x00,//3
	0x00,0x0c,0x14,0x24,0x7f,0x04,0x00,0x00,//4
	0x00,0x72,0x51,0x51,0x51,0x4e,0x00,0x00,//5
	0x00,0x3e,0x49,0x49,0x49,0x26,0x00,0x00,//6
	0x00,0x40,0x40,0x40,0x4f,0x70,0x00,0x00,//7
	0x00,0x36,0x49,0x49,0x49,0x36,0x00,0x00,//8
	0x00,0x32,0x49,0x49,0x49,0x3e,0x00,0x00,//9
};


void ledscreen()
{
	uch8 i,j;uch8 time_delay=30;	

	for(i=0;i<10;i++)
	{
		while(time_delay--)
		{
			en_row_leds=0x01;   //列选变量初值设置
		
			for(j=0;j<8;j++)
			{
				P3=en_row_leds; //列选通	
				P0=~code_row_leds[i*8+j];//输出列码
				delay1ms(5);		//延时
				en_row_leds=_crol_(en_row_leds,1);//获取下一个列选指令	
			}
		}
		time_delay=30;
	}
}
