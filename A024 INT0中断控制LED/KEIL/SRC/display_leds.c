/*****************************************************************************
** display.c:8*8LED点阵屏显示程序
** 项 目 人:
** 建立时间:
** 修 改 人：
** 修改描述
*****************************************************************************/


#include "config.h"
#include "intrins.h"

uch8 code code_display_leds[]=
{
 	0x00,0x3e,0x41,0x41,0x41,0x3e,0x00,0x00,
	0x00,0x00,0x00,0x21,0x7f,0x01,0x00,0x00,
	0x00,0x27,0x45,0x45,0x45,0x39,0x00,0x00,
	0x00,0x22,0x49,0x49,0x49,0x36,0x00,0x00,
	0x00,0x0c,0x14,0x24,0x7f,0x04,0x00,0x00,
	0x00,0x72,0x51,0x51,0x51,0x4e,0x00,0x00,
	0x00,0x3e,0x49,0x49,0x49,0x26,0x00,0x00,
	0x00,0x40,0x40,0x40,0x4f,0x70,0x00,0x00,
	0x00,0x36,0x49,0x49,0x49,0x36,0x00,0x00,
	0x00,0x32,0x49,0x49,0x49,0x3e,0x00,0x00,
};

void display_leds()
{
	uch8 i,j;
	uch8 line_leds;
    uint16 time_delay=30;

	for(i=0;i<10;i++)
	{
		while(time_delay--)
		{
			line_leds=0x01;
	
			for(j=0;j<8;j++) //显示单个数字
			{			
				P3=line_leds;
				P0=~code_display_leds[i*8+j];
				delay1ms(5);
				line_leds=_crol_(line_leds,1);//列扫描显示
			}
		}
        time_delay=30;
	}
}
