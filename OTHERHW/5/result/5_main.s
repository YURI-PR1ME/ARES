    AREA    RESET, DATA, READONLY
    EXPORT  __Vectors

__Vectors
    DCD     0x20001000          ; 栈顶地址 (Initial Stack Pointer)
    DCD     __main              ; 复位向量 (Reset Vector)

; --- 定义数据段 ---
    AREA    MyData, DATA, READONLY
Array   DCD     5, 8, 12, 9, 10, 3, 5, 7, 8, 10, 22, 31, 17, 16, 13
ArrayEnd

; --- 定义代码段 ---
    AREA    |.text|, CODE, READONLY
    ENTRY                           ; 标记程序入口
    EXPORT  __main

__main
    ; -----------------------------------------------------------
    ; 初始化堆栈
    ; -----------------------------------------------------------
    LDR     SP, =0x20001000         ; 初始化堆栈指针
    
    ; -----------------------------------------------------------
    ; 初始化变量
    ; -----------------------------------------------------------
    LDR     R0, =Array              ; R0 = 数组的首地址
    LDR     R7, =Array
    MOV     R1, #15                 ; R1 = 循环次数
    MOV     R10, #0
    MOV     R5, #0
    MOV     R6, #0
    
    ; -----------------------------------------------------------
    ; ARM/THUMB模式切换验证
    ; -----------------------------------------------------------
    ; 首先在ARM模式下读取
    LDR     R2, [R0, #4]            ; R2读取R0+4地址的值
    
    ; 切换到THUMB模式
    ADR     R4, thumb_code + 1      ; 获取THUMB代码地址，最低位设为1
    BX      R4                      ; 跳转到THUMB模式
    
    ; THUMB代码段
    CODE16
thumb_code
    LDR     R3, [R0, #4]            ; R3读取R0+4地址的值
    ; 切换回ARM模式
    ADR     R4, arm_code
    BX      R4
    
    ; ARM代码段
    CODE32
arm_code
    ; 现在回到ARM模式，可以继续执行
    NOP                             ; 占位符，可以添加其他代码
    
    ; -----------------------------------------------------------
    ; 继续原来的循环
    ; -----------------------------------------------------------
Loop_Window
    CMP     R1, #0                  ; 检查计数器
    BEQ     Stop                    ; 结束
    
    ; 循环处理代码...
    ; 这里可以继续你的循环逻辑
    
Stop
    B       Stop                    ; 死循环

    END
