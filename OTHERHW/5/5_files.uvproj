# Keil uVision project 5_files.uvproj, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: 5_files
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x40000000 size 0x10000
  group Source Group 1
    ./: 5_main.s
